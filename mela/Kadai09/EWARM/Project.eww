<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Kadai09.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\Kadai10\EWARM\Kadai10.ewp</path>
    </project>
    <batchBuild />
</workspace>
